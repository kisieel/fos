# Keil uVision project monster_fish.uvprojx, settings and files
target Monster_fish (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: monster_fish +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L1XX_MD
  c include: .\dev;.\inc;.\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group dev
    ./dev/: startup_stm32l1xx_md.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
  group inc
    ./inc/: EEPROM.h RFM69W.h USART.h KEY.h MENU.h LOW_MODE.h RTC.h FLOAT.h SYS_TICK.h HALL.h main.h BUZZER.h LED.h
  group src
    ./src/: EEPROM.c main.c RFM69W.c USART.c KEY.c MENU.c LOW_MODE.c RTC.c FLOAT.c SYS_TICK.c HALL.c BUZZER.c LED.c
